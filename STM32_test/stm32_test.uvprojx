# Keil uVision project stm32_test.uvprojx, settings and files
target stm32_test (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: stm32_test +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\library\CM3\CoreSupport;.\include;.\hal;.\user
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group user
    ./user/: main.c delay.c delay.h
  group library
    ./library/: stm32f10x_gpio.c misc.c stm32f10x_rcc.c stm32f10x_tim.c
  group include
    ./include/: stm32f10x_gpio.h
  group hal
    ./hal/: hal_key.c Hal_key.h Hal_led.c Hal_led.h hal_motor.c Hal_motor.h
    ./library/: misc.c stm32f10x_rcc.c
software components: Device:GPIO 1.01.0, Device:Startup 1.0.0
